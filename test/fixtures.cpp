#include "fixtures.h"
#include <gtest/gtest.h>
#include <log.h>
#include <vector>
#include <fstream>
#include <filesystem>
#include <sys/stat.h>
#define STB_IMAGE_WRITE_IMPLEMENTATION
#include "stb_image_write.h"

using namespace std;
namespace fixtures {

std::string fmtstr(const char* fmt, ... ) {
    char buf[128];
    va_list args;
    va_start(args, fmt);
    vsnprintf(buf, sizeof(buf), fmt, args);
    va_end(args);
    return std::string(buf);
}
std::string basename(const std::string& path) {
    size_t pos = path.find_last_of("/\\");
    return (pos == std::string::npos) ? path : path.substr(pos + 1);
}

std::string testname() {
    auto tst = ::testing::UnitTest::GetInstance()->current_test_info();
    return string(tst->test_suite_name()) + "." + tst->name();
}

std::string cwd() {
    return std::filesystem::current_path();
}

void draw_lvgl_png(lv_disp_drv_t* drv, const char* path) {
    if (!drv || !drv->draw_buf) return;
    int w = drv->hor_res;
    int h = drv->ver_res;
    lv_color_t* cbuf = (lv_color_t*)drv->draw_buf->buf1;
    std::vector<uint8_t> rgb888(w * h * 3);
    for (int i = 0; i < w * h; i++) {
        // LVGL color to RGB888
        rgb888[i * 3 + 0] = (cbuf[i].ch.red << 3) | (cbuf[i].ch.red >> 2);
        rgb888[i * 3 + 1] = (cbuf[i].ch.green << 2) | (cbuf[i].ch.green >> 4);
        rgb888[i * 3 + 2] = (cbuf[i].ch.blue << 3) | (cbuf[i].ch.blue >> 2);
    }
    auto res = stbi_write_png(path, w, h, 3, rgb888.data(), w * 3);
    MAP_LOG("draw_lvgl_to_png wrote %s [%dx%d] -> res %d", path, w, h, res);
}

// A minimal 4x4 rainbow png. starts with r, g, b, w, then more rainbow for the rest.
const std::vector<uint8_t> png4x4 = {
    0x89,0x50,0x4e,0x47,0x0d,0x0a,0x1a,0x0a,0x00,0x00,0x00,0x0d,0x49,0x48,0x44,0x52,0x00,0x00,0x00,0x04,
    0x00,0x00,0x00,0x04,0x08,0x06,0x00,0x00,0x00,0xa9,0xf1,0x9e,0x7e,0x00,0x00,0x00,0x01,0x73,0x52,0x47,
    0x42,0x00,0xae,0xce,0x1c,0xe9,0x00,0x00,0x00,0x44,0x65,0x58,0x49,0x66,0x4d,0x4d,0x00,0x2a,0x00,0x00,
    0x00,0x08,0x00,0x01,0x87,0x69,0x00,0x04,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x1a,0x00,0x00,0x00,0x00,
    0x00,0x03,0xa0,0x01,0x00,0x03,0x00,0x00,0x00,0x01,0x00,0x01,0x00,0x00,0xa0,0x02,0x00,0x04,0x00,0x00,
    0x00,0x01,0x00,0x00,0x00,0x04,0xa0,0x03,0x00,0x04,0x00,0x00,0x00,0x01,0x00,0x00,0x00,0x04,0x00,0x00,
    0x00,0x00,0xc5,0x6c,0xfe,0x02,0x00,0x00,0x00,0x4a,0x49,0x44,0x41,0x54,0x08,0x1d,0x63,0xfc,0xcf,0xc0,
    0xf0,0x9f,0x11,0x48,0x30,0x00,0x89,0xff,0x40,0x9a,0xf1,0x79,0x9c,0xc5,0x7f,0x5e,0xb7,0x3f,0x0c,0x0c,
    0x36,0x2c,0x0c,0x9b,0xbe,0xbe,0x62,0x60,0xe1,0xf5,0xfc,0xcb,0xf0,0xdf,0x92,0x8d,0x61,0xf5,0xa7,0x17,
    0x0c,0xcd,0x47,0xff,0x30,0xb0,0xfc,0xb7,0x64,0x65,0x58,0xf2,0xe1,0x19,0x43,0xf7,0x51,0x66,0x06,0xe6,
    0x9d,0x1d,0x0c,0x00,0x75,0x00,0x1a,0x4b,0x11,0x58,0xf6,0xc5,0x00,0x00,0x00,0x00,0x49,0x45,0x4e,0x44,
    0xae,0x42,0x60,0x82,
};
const std::vector<uint8_t> png256hi = {
    0x89,0x50,0x4e,0x47,0x0d,0x0a,0x1a,0x0a,0x00,0x00,0x00,0x0d,0x49,0x48,0x44,0x52,0x00,0x00,0x01,0x00,
    0x00,0x00,0x01,0x00,0x01,0x03,0x00,0x00,0x00,0x66,0xbc,0x3a,0x25,0x00,0x00,0x00,0x06,0x50,0x4c,0x54,
    0x45,0xaa,0xd3,0xdf,0x00,0x00,0xff,0x80,0x80,0xc8,0x8c,0x00,0x00,0x00,0x43,0x49,0x44,0x41,0x54,0x68,
    0xde,0xed,0xd1,0xb9,0x0d,0x00,0x21,0x0c,0x45,0x41,0x97,0xb6,0xa5,0x6d,0xc9,0x74,0x60,0xa8,0x00,0x11,
    0x20,0x2e,0xcd,0xc8,0xe1,0x0b,0x2c,0xfd,0x28,0xd1,0x37,0x25,0x00,0xb6,0xf9,0xdb,0x3d,0x12,0x7c,0x07,
    0xfc,0x20,0x98,0x10,0x64,0xe6,0xc8,0xdc,0x02,0xc1,0xca,0x20,0x5a,0x00,0x00,0x00,0x00,0x00,0x00,0xdc,
    0xad,0x02,0xb7,0x69,0x33,0xfe,0x5b,0x13,0x05,0xaa,0x00,0x00,0x00,0x00,0x49,0x45,0x4e,0x44,0xae,0x42,
    0x60,0x82,
};

TmpFileHelper::TmpFileHelper(const std::vector<uint8_t> &img, string fn) {
    fn_ = fn.empty()? fmtstr("/tmp/testpng_%d.png", img.size()) : fn;
    std::ofstream ofs(fn_, std::ios::binary);
    ofs.write((const char*) img.data(), img.size());
    ofs.close();
}
void TmpFileHelper::rm() { remove(fn_.c_str()); }


LvglTestEnv::LvglTestEnv(uint16_t width, uint16_t height) { reset(width, height); }

LvglTestEnv::~LvglTestEnv() {
    reset();
}

void LvglTestEnv::reset(uint16_t width, uint16_t height) {
    width_ = width;
    height_ = height;
    buf_.resize(width_ * height_);
    if (canvas_) {
        lv_obj_del(canvas_);
        canvas_ = nullptr;
    }
    if (width_ == 0 || height_ == 0) { //de-init
        lv_deinit();
    } else {
        lv_init();
        lv_disp_draw_buf_init(&draw_buf_, buf_.data(), NULL, width_ * height_);
        lv_disp_drv_init(&disp_drv_);
        disp_drv_.draw_buf = &draw_buf_;
        disp_drv_.hor_res = width_;
        disp_drv_.ver_res = height_;
        disp_drv_.flush_cb = [](lv_disp_drv_t* d, const lv_area_t*, lv_color_t*) { lv_disp_flush_ready(d); };
        lv_disp_drv_register(&disp_drv_);

        canvas_ = lv_canvas_create(lv_scr_act());
        lv_canvas_set_buffer(canvas_, buf_.data(), width_, height_, LV_IMG_CF_TRUE_COLOR);
        lv_canvas_fill_bg(canvas_, lv_color_hex(0x000000), LV_OPA_COVER);
    }
}

void LvglTestEnv::draw() {
    lv_task_handler();
}

void LvglTestEnv::save() {
    filesystem::path dir = filesystem::current_path() / "testoutputs";
    try {
        filesystem::create_directories(dir);
        auto fn = dir / ("test_" + testname() + "_canvas.png");
        draw_lvgl_png(&disp_drv_, fn.c_str());
    } catch (const filesystem::filesystem_error& e) {
        MAP_LOG("fs error %s", e.what());
    }
}

} //fixtures
